# Keil uVision project 2D-LASER.uvprojx, settings and files
target 2D-LASER (ARM-ADS)
  device: STM32F302CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: CBT6
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302xC
  c misc: --C99
  c include: ..\HAL\Inc;..\HAL\Drivers\CMSIS\Include;..\HAL\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\HAL\Drivers\STM32F3xx_HAL_Driver\Inc;..\HAL\Drivers\STM32F3xx_HAL_Driver\Inc\Legacy;..\Source;..\protocol;..\USER;..\Bsp\angle_and_speed;..\Bsp\ccd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../HAL/Src/: system_stm32f3xx.c
  group Application/MDK-ARM
    ./: startup_stm32f302xc.s
  group Application/User
    ../HAL/Src/: adc.c dma.c gpio.c i2c.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c tim.c usart.c
  group Drivers/STM32F3xx_HAL_Driver
    ../HAL/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_uart.c stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart_ex.c
  group Source
    ../Source/: adc_user.c gpio_user.c laser.c delay_user.c usart_user.c
  group protocol
    ../protocol/: rec.c transmit.c
  group USER
    ../USER/: sysconfig.c
  group bsp
    ../Bsp/angle_and_speed/: angle_and_speed.c
    ../Bsp/ccd/: epc.c
software components: CMSIS:CORE 4.1.0
